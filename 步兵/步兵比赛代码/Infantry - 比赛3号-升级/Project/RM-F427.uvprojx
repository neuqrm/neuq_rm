# Keil uVision project RM-F427.uvprojx, settings and files
target INFANRY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM_typeA +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,
  c misc: --c99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\APP;..\Hardware;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash_md5.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_hash.c
  group USER
    ../User/: main.c stm32f4xx_it.c
  group APP
    ../APP/: remote.c motor.c motion.c limit.c
    ../Hardware/: json.c
  group HARDWARE
    ../Hardware/: CAN_receive.c pid.c imu.c referee.c debug.c filter.c CRC8_CRC16.c
  group BSP
    ../BSP/: bsp_advance_tim.c bsp_can.c bsp_dbus.c bsp_led.c bsp_key.c bsp_power.c bsp_SysTick.c bsp_debug_usart.c bsp_referee_usart.c bsp_supercap_usart.c bsp_imu_usart.c bsp_json_usart.c bsp_basic_tim.c
  group DOC
    ../Doc/: readme.txt
software components: Data Exchange:JSON:Jansson 2.7.0
