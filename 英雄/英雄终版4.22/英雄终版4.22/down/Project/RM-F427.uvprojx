# Keil uVision project RM-F427.uvprojx, settings and files
target 底盘 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM_typeA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,
  c misc: --c99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\delay;..\Hardware\LED;..\Hardware\motor;..\Hardware\STMFLASH;..\Hardware\flash;..\Hardware\power;..\Hardware\key;..\Hardware\BUZZER;..\Hardware\remote_code;..\Hardware\TIM3_Events;..\APP\kinematic;..\APP\angle_pid;..\APP\speed_pid;..\APP\json;..\BSP\usart;..\BSP\timer;..\BSP\can;..\User\Init;..\Hardware\fric;..\APP\mode;..\Hardware\gimbal;..\APP\judge;..\Hardware\imuReader;..\User\sys;..\User\algorithm;..\APP\encoder;..\APP\shoot;..\APP\remote;..\APP\bsp_dbus;..\BSP\bsp_referee_usart;..\BSP\referee;..\BSP\led;..\Hardware\power_limitation;..\Hardware\debug_usart;..\BSP\bsp_supercap_usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash_md5.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_hash.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/delay/: delay.c
    ../User/sys/: sys.c
    ../User/Init/: My_Init.c
    ../User/algorithm/: algorithm.c
  group APP
    ../APP/angle_pid/: angle_pid.c
    ../APP/speed_pid/: speed_pid.c
    ../APP/json/: json.c
    ../APP/shoot/: shoot.c
    ../APP/mode/: mode.c
    ../APP/judge/: judge.c
    ../APP/encoder/: encoder.c
    ../APP/bsp_dbus/: bsp_dbus.c
  group BSP
    ../BSP/timer/: timer.c
    ../BSP/can/: can.c
    ../BSP/usart/: bsp_uart7.c uart5.c bsp_imu_usart.c
    ../BSP/bsp_referee_usart/: bsp_referee_usart.c
    ../BSP/referee/: referee.c
    ../BSP/led/: bsp_led.c
    ../BSP/bsp_supercap_usart/: bsp_supercap_usart.c
  group HARDWARE
    ../Hardware/LED/: LED.c
    ../Hardware/motor/: motor.c
    ../Hardware/flash/: myflash.c
    ../Hardware/STMFLASH/: stmflash.c
    ../Hardware/power/: power.c
    ../Hardware/key/: key.c
    ../Hardware/BUZZER/: buzzer.c
    ../Hardware/remote_code/: remote_code.c
    ../Hardware/TIM3_Events/: Tim3_Events.c
    ../Hardware/fric/: fric.c
    ../Hardware/gimbal/: gimbal.c
    ../Hardware/power_limitation/: power_limitation.c
    ../Hardware/imuReader/: imuReader.c
    ../Hardware/debug_usart/: bsp_debug_usart.c
    ../APP/kinematic/: kinematic.c
  group DOC
    ../Doc/: 说明.txt
software components: Data Exchange:JSON:Jansson 2.7.0
