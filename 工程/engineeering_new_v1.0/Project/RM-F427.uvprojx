# Keil uVision project RM-F427.uvprojx, settings and files
target 底盘 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM_typeA
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,
  c misc: --c99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\delay;..\Hardware\LED;..\Hardware\motor;..\Hardware\STMFLASH;..\Hardware\flash;..\Hardware\power;..\Hardware\key;..\Hardware\BUZZER;..\Hardware\DJi_remote;..\Hardware\FS_remote;..\Hardware\remote_code;..\Hardware\TIM3_Events;..\APP\kinematic;..\APP\angle_pid;..\APP\speed_pid;..\APP\json;..\BSP\usart;..\BSP\timer;..\BSP\can;..\User\Init;..\Hardware\fric;..\APP\mode;..\Hardware\gimbal;..\APP\judge;..\Hardware\imuReader;..\User\sys;..\User\algorithm;..\Hardware\steering_engine;..\Hardware\stepper_motor;..\APP\referee;..\APP\remote;..\APP\bsp_dbus;..\APP\bsp_led;..\Hardware\solenoid_valve;..\Hardware\limit_switch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash_md5.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_hash.c stm32f4xx_exti.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/delay/: delay.c
    ../User/sys/: sys.c
    ../User/Init/: My_Init.c
    ../User/algorithm/: algorithm.c
  group APP
    ../APP/kinematic/: kinematic.c
    ../APP/angle_pid/: angle_pid.c
    ../APP/speed_pid/: speed_pid.c
    ../APP/judge/: judge.c
    ../APP/remote/: remote.c
    ../APP/referee/: referee.c
    ../APP/bsp_led/: bsp_led.c
    ../APP/bsp_dbus/: bsp_dbus.c
  group BSP
    ../BSP/usart/: bsp_debug_usart.c uart5.c
    ../BSP/timer/: timer.c
    ../BSP/can/: can.c
  group HARDWARE
    ../Hardware/LED/: LED.c
    ../Hardware/motor/: motor.c
    ../Hardware/power/: power.c
    ../Hardware/key/: key.c
    ../Hardware/remote_code/: remote_code.c
    ../Hardware/TIM3_Events/: Tim3_Events.c
    ../Hardware/steering_engine/: steering_engine.c
    ../Hardware/stepper_motor/: stepper_motor.c
    ../Hardware/solenoid_valve/: solenoid_valve.c
    ../Hardware/limit_switch/: limit_switch.c
  group DOC
    ../Doc/: 说明.txt
software components: Data Exchange:JSON:Jansson 2.7.0
